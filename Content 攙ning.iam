# Autodesk Inventor assembly: Content övning
## iProperties
Created: 2007-05
Part Number: Content övning
Document SubType Name: Assembly
Designer: Tobben
Author: Tobben
